# IAR project First.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F407VE ST STM32F407VE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F407VE; STM32F40_41xxx; VECT_TAB_SRAM; HSE_VALUE=8000000
  ICCARM.CCIncludePath2: ; ..\..\..\Common\ST\STM32F4xx_DSP_StdPeriph_Lib_V1.5.1\Libraries\CMSIS\Device\ST\STM32F4xx\Include\; ..\..\..\Common\ST\STM32F4xx_DSP_StdPeriph_Lib_V1.5.1\Libraries\CMSIS\Device\ST\STM32F4xx\Include\; ..\..\..\Common\ST\STM32F4xx_DSP_StdPeriph_Lib_V1.5.1\Libraries\CMSIS\Include\; ..\..\..\Common\ST\STM32F4xx_DSP_StdPeriph_Lib_V1.5.1\Project\STM32F4xx_StdPeriph_Templates\; ..\..\..\Common\ST\STM32F4xx_DSP_StdPeriph_Lib_V1.5.1\Libraries\STM32F4xx_StdPeriph_Driver\inc\; ..\..\..\Common\ST\STM32F4xx_DSP_StdPeriph_Lib_V1.5.1\Libraries\STM32F4xx_StdPeriph_Driver\src\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.ADefines: VECT_TAB_SRAM
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkIcfFile: D:\ArmProj\Common\ST\icf\stm32f407xG_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  General.CoreVariant: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ./: BeeOS.c BeeOS.h BeeOS_Tasks.h heap.h heap_1.c main.c stm32f4xx_it.c stm32f4xx_it.h system_stm32f4xx.c
    ../../../Common/ST/STM32F4xx_DSP_StdPeriph_Lib_V1.5.1/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40_41xxx.s
    ../../../Common/ST/STM32F4xx_DSP_StdPeriph_Lib_V1.5.1/Libraries/STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c
